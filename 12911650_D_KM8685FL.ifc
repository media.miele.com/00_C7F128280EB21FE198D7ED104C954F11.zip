Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 5fdb1cac-79ec-497e-8c78-23beff029d05, NumberOfSaves: 1]
File name: 0001
Time: 2026-06-03T12:12:01+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12911650_D_KM8685FL:26I86851_D_12911650_KM8685FL, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 800 mm; Height: 51 mm; Depth: 520 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Connection_Compressed_Air, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - Reference: 26I86851_D_12911650_KM8685FL; sets with these values: 2
